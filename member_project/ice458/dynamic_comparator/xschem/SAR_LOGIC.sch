v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 300 -20 300 140 {
lab=#net1}
N 300 140 340 140 {
lab=#net1}
N 640 100 640 200 {
lab=en3}
N 640 200 660 200 {
lab=en3}
N 620 180 660 180 {
lab=cmp_p}
N 620 180 620 240 {
lab=cmp_p}
N -100 240 620 240 {
lab=cmp_p}
N -100 -0 -100 240 {
lab=cmp_p}
N -100 -10 -100 -0 {
lab=cmp_p}
N -100 -10 -70 -10 {
lab=cmp_p}
N -120 -10 -100 -10 {
lab=cmp_p}
N -120 -30 -70 -30 {
lab=cmp_n}
N 800 -20 800 140 {
lab=#net1}
N 800 140 840 140 {
lab=#net1}
N 1140 100 1140 200 {
lab=en2}
N 1140 200 1160 200 {
lab=en2}
N 1120 180 1160 180 {
lab=cmp_p}
N 1120 180 1120 240 {
lab=cmp_p}
N 1300 -20 1300 140 {
lab=#net1}
N 1300 140 1340 140 {
lab=#net1}
N 1640 100 1640 200 {
lab=en1}
N 1640 200 1660 200 {
lab=en1}
N 1620 180 1660 180 {
lab=cmp_p}
N 1620 180 1620 240 {
lab=cmp_p}
N 300 -20 1300 -20 {
lab=#net1}
N 10 -100 10 -60 {
lab=vdd}
N -120 -100 10 -100 {
lab=vdd}
N 10 -100 430 -100 {
lab=vdd}
N 430 -100 430 70 {
lab=vdd}
N 320 120 340 120 {
lab=vdd}
N 320 -100 320 120 {
lab=vdd}
N 430 -100 750 -100 {
lab=vdd}
N 750 -100 750 130 {
lab=vdd}
N 930 -100 930 70 {
lab=vdd}
N 750 -100 930 -100 {
lab=vdd}
N 1250 -100 1250 130 {
lab=vdd}
N 930 -100 1250 -100 {
lab=vdd}
N 1430 -100 1430 70 {
lab=vdd}
N 1260 -100 1430 -100 {
lab=vdd}
N 1250 -100 1260 -100 {
lab=vdd}
N 1750 -100 1750 130 {
lab=vdd}
N 1430 -100 1750 -100 {
lab=vdd}
N -120 -80 40 -80 {
lab=vss}
N 40 -80 40 -60 {
lab=vss}
N 40 -80 450 -80 {
lab=vss}
N 450 -80 450 70 {
lab=vss}
N 450 -80 770 -80 {
lab=vss}
N 770 -80 770 130 {
lab=vss}
N 770 -80 950 -80 {
lab=vss}
N 950 -80 950 70 {
lab=vss}
N 950 -80 1270 -80 {
lab=vss}
N 1270 -80 1270 130 {
lab=vss}
N 1270 -80 1450 -80 {
lab=vss}
N 1450 -80 1450 70 {
lab=vss}
N 1450 -80 1770 -80 {
lab=vss}
N 1770 -80 1770 130 {
lab=vss}
N 640 120 840 120 {
lab=en3}
N 1140 120 1340 120 {
lab=en2}
N 1300 -20 1800 -20 {
lab=#net1}
N 1800 -20 1800 140 {
lab=#net1}
N 1800 140 1840 140 {
lab=#net1}
N 1640 120 1840 120 {
lab=en1}
N 1930 -100 1930 70 {
lab=vdd}
N 1750 -100 1930 -100 {
lab=vdd}
N 1770 -80 1950 -80 {
lab=vss}
N 1950 -80 1950 70 {
lab=vss}
N 1840 40 1840 100 {
lab=rst}
N -120 40 1840 40 {
lab=rst}
N 340 40 340 100 {
lab=rst}
N 660 40 660 160 {
lab=rst}
N 840 40 840 100 {
lab=rst}
N 1160 40 1160 160 {
lab=rst}
N 1340 40 1340 100 {
lab=rst}
N 1660 40 1660 160 {
lab=rst}
N 640 200 640 260 {
lab=en3}
N 960 160 960 260 {
lab=D3}
N 660 260 960 260 {
lab=D3}
N 640 560 640 580 {
lab=vdd}
N 280 580 640 580 {
lab=vdd}
N 280 -100 280 580 {
lab=vdd}
N 260 -80 260 600 {
lab=vss}
N 260 600 660 600 {
lab=vss}
N 660 560 660 600 {
lab=vss}
N 1140 200 1140 260 {
lab=en2}
N 1460 160 1460 260 {
lab=D2}
N 1160 260 1460 260 {
lab=D2}
N 1140 560 1140 580 {
lab=vdd}
N 780 580 1140 580 {
lab=vdd}
N 760 600 1160 600 {
lab=vss}
N 1160 560 1160 600 {
lab=vss}
N 1640 200 1640 260 {
lab=en1}
N 1960 160 1960 260 {
lab=D1}
N 1660 260 1960 260 {
lab=D1}
N 1640 560 1640 580 {
lab=vdd}
N 1280 580 1640 580 {
lab=vdd}
N 1260 600 1660 600 {
lab=vss}
N 1660 560 1660 600 {
lab=vss}
N 1140 580 1280 580 {
lab=vdd}
N 640 580 780 580 {
lab=vdd}
N 660 600 760 600 {
lab=vss}
N 1160 600 1260 600 {
lab=vss}
N 620 240 1120 240 {
lab=cmp_p}
N 1120 240 1620 240 {
lab=cmp_p}
N 960 260 960 320 {
lab=D3}
N 1460 260 1460 320 {
lab=D2}
N 1960 260 1960 320 {
lab=D1}
N 680 560 680 620 {
lab=s33}
N 700 560 700 620 {
lab=s32}
N 720 560 720 620 {
lab=s31}
N 1180 560 1180 620 {
lab=s23}
N 1200 560 1200 620 {
lab=s22}
N 1220 560 1220 620 {
lab=s21}
N 1680 560 1680 620 {
lab=s13}
N 1700 560 1700 620 {
lab=s12}
N 1720 560 1720 620 {
lab=s11}
N 2560 330 2600 330 {
lab=#net2}
N 2560 200 2600 200 {
lab=#net3}
N 2600 200 2600 310 {
lab=#net3}
N 2900 270 2900 320 {
lab=#net4}
N 2380 330 2380 400 {
lab=#net5}
N 2380 400 3380 400 {
lab=#net5}
N 3380 400 3400 400 {
lab=#net5}
N 3400 260 3400 400 {
lab=#net5}
N 3380 260 3400 260 {
lab=#net5}
N 2900 110 2900 250 {
lab=regclk}
N 2900 100 2900 110 {
lab=regclk}
N 2140 100 2900 100 {
lab=regclk}
N 2380 0 2380 200 {
lab=d}
N 3400 260 3460 260 {
lab=#net5}
N 3460 260 3490 260 {
lab=#net5}
N 3420 240 3490 240 {
lab=d}
N 3400 240 3420 240 {
lab=d}
N 3400 0 3400 240 {
lab=d}
N 2280 -0 3400 0 {
lab=d}
N 1930 -100 3790 -100 {
lab=vdd}
N 3790 -100 3790 220 {
lab=vdd}
N 3790 260 3800 260 {
lab=vss}
N 3800 -80 3800 260 {
lab=vss}
N 1950 -80 3800 -80 {
lab=vss}
N 2280 -100 2280 -20 {
lab=vdd}
N 2280 20 2300 20 {
lab=vss}
N 2300 -80 2300 20 {
lab=vss}
N 2420 -100 2420 150 {
lab=vdd}
N 2440 -80 2440 150 {
lab=vss}
N 2320 280 2420 280 {
lab=vdd}
N 2320 -100 2320 280 {
lab=vdd}
N 2340 -80 2340 260 {
lab=vss}
N 2340 260 2440 260 {
lab=vss}
N 2440 260 2440 280 {
lab=vss}
N 2680 -100 2680 280 {
lab=vdd}
N 2710 -80 2710 280 {
lab=vss}
N 2980 -100 2980 220 {
lab=vdd}
N 3010 -80 3010 220 {
lab=vss}
N 3240 -100 3240 210 {
lab=vdd}
N 3260 -80 3260 210 {
lab=vss}
N 930 260 930 440 {
lab=D3}
N 970 -100 970 390 {
lab=vdd}
N 990 -80 990 390 {
lab=vss}
N 4040 240 4200 240 {
lab=#net6}
N 4200 180 4200 240 {
lab=#net6}
N 4200 120 4200 160 {
lab=#net7}
N 3710 120 4020 120 {
lab=cmp1st}
N 3790 -100 4280 -100 {
lab=vdd}
N 4280 -100 4280 130 {
lab=vdd}
N 4060 -100 4060 70 {
lab=vdd}
N 3800 -80 4310 -80 {
lab=vss}
N 4310 -80 4310 130 {
lab=vss}
N 4080 -80 4080 70 {
lab=vss}
N 3920 -80 3920 190 {
lab=vss}
N 3900 -100 3900 190 {
lab=vdd}
N 3440 220 3490 220 {
lab=vss}
N 3440 -80 3440 220 {
lab=vss}
N 4580 -100 4580 140 {
lab=vdd}
N 4280 -100 4580 -100 {
lab=vdd}
N 4310 -80 4610 -80 {
lab=vss}
N 4610 -80 4610 140 {
lab=vss}
N 4470 340 4500 340 {
lab=#net8}
N 4500 190 4500 340 {
lab=#net8}
N 3840 290 4330 290 {
lab=vdd}
N 3840 -100 3840 290 {
lab=vdd}
N 4350 280 4350 290 {
lab=vss}
N 3850 280 4350 280 {
lab=vss}
N 3850 -80 3850 280 {
lab=vss}
N 1840 40 3820 40 {
lab=rst}
N 3820 40 3820 340 {
lab=rst}
N 3820 340 4290 340 {
lab=rst}
N 3790 240 3860 240 {
lab=#net9}
N 230 -260 230 -20 {
lab=#net1}
N 230 -260 670 -260 {
lab=#net1}
N 970 -240 1040 -240 {
lab=#net10}
N 970 -220 1000 -220 {
lab=vss}
N 1000 -220 1000 -80 {
lab=vss}
N 970 -260 1030 -260 {
lab=vdd}
N 1030 -260 1030 -100 {
lab=vdd}
N 230 -20 300 -20 {
lab=#net1}
N 1040 -240 1980 -240 {
lab=#net10}
N 1980 -240 1980 -20 {
lab=#net10}
N 4580 -100 4840 -100 {}
N 4840 -100 4840 130 {}
N 4860 -80 4860 130 {}
N 4610 -80 4860 -80 {}
C {nand.sym} 80 -10 0 0 {name=x1}
C {rs_ff.sym} 490 120 0 0 {name=x2}
C {rs_ff.sym} 810 180 0 0 {name=x3}
C {devices/ipin.sym} -120 -10 0 0 {name=p1 lab=cmp_p}
C {devices/ipin.sym} -120 -30 0 0 {name=p2 lab=cmp_n}
C {rs_ff.sym} 990 120 0 0 {name=x4}
C {rs_ff.sym} 1310 180 0 0 {name=x5}
C {rs_ff.sym} 1490 120 0 0 {name=x6}
C {rs_ff.sym} 1810 180 0 0 {name=x7}
C {devices/iopin.sym} -120 -100 2 0 {name=p3 lab=vdd}
C {devices/iopin.sym} -120 -80 2 0 {name=p4 lab=vss}
C {rs_ff.sym} 1990 120 0 0 {name=x8}
C {devices/ipin.sym} -120 40 0 0 {name=p5 lab=rst}
C {decode.sym} 680 410 3 1 {name=x9}
C {decode.sym} 1180 410 3 1 {name=x10}
C {decode.sym} 1680 410 3 1 {name=x11}
C {devices/opin.sym} 960 320 1 0 {name=p6 lab=D3}
C {devices/opin.sym} 1460 320 1 0 {name=p7 lab=D2}
C {devices/opin.sym} 1960 320 1 0 {name=p8 lab=D1}
C {devices/opin.sym} 680 620 1 0 {name=p9 lab=s33}
C {devices/opin.sym} 700 620 1 0 {name=p10 lab=s32}
C {devices/opin.sym} 720 620 1 0 {name=p11 lab=s31}
C {devices/opin.sym} 1180 620 1 0 {name=p12 lab=s23}
C {devices/opin.sym} 1200 620 1 0 {name=p13 lab=s22}
C {devices/opin.sym} 1220 620 1 0 {name=p14 lab=s21}
C {devices/opin.sym} 1680 620 1 0 {name=p15 lab=s13}
C {devices/opin.sym} 1700 620 1 0 {name=p16 lab=s12}
C {devices/opin.sym} 1720 620 1 0 {name=p17 lab=s11}
C {delay.sym} 820 -240 0 0 {name=x12}
C {nand.sym} 2750 330 0 0 {name=x13}
C {inv.sym} 2460 200 0 0 {name=x14}
C {inv.sym} 2460 330 0 0 {name=x15}
C {nand.sym} 3050 270 0 0 {name=x16}
C {inv.sym} 3280 260 0 0 {name=x17}
C {nor31.sym} 3640 240 0 0 {name=x18}
C {devices/ipin.sym} 3710 120 0 0 {name=p18 lab=cmp1st}
C {devices/opin.sym} 4980 180 0 0 {name=p19 lab=cmpclk}
C {devices/opin.sym} 2190 100 1 0 {name=p20 lab=regclk}
C {devices/lab_pin.sym} 720 120 1 0 {name=p21 sig_type=std_logic lab=en3
}
C {devices/lab_pin.sym} 3400 0 1 0 {name=p22 sig_type=std_logic lab=d
}
C {devices/lab_pin.sym} 1110 440 3 0 {name=p23 sig_type=std_logic lab=d3d
}
C {devices/lab_pin.sym} 830 240 3 0 {name=p24 sig_type=std_logic lab=cmp_p
}
C {inv.sym} 1010 440 0 0 {name=x20}
C {nand.sym} 4350 180 0 0 {name=x19}
C {inv.sym} 3940 240 0 0 {name=x21}
C {inv.sym} 4100 120 0 0 {name=x22}
C {nand.sym} 4650 190 0 0 {name=x23}
C {inv.sym} 4370 340 0 0 {name=x24}
C {inv.sym} 4880 180 0 0 {name=x25}
C {delay.sym} 2130 0 0 0 {name=x26}
C {devices/lab_pin.sym} 1230 120 1 0 {name=p25 sig_type=std_logic lab=en2
}
C {devices/lab_pin.sym} 1670 120 1 0 {name=p26 sig_type=std_logic lab=en1}
